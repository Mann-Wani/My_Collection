ORG 0000H 
	
; SAVE LARGEST IN 34 , SMALLEST IN 35 
; ARRAY IN 30,31,32,33 
; ARRAY POINTER IN 40 
; U NEED TO COMPARE [40H] AND [40H+I]

MOV R0,#30H
MOV R2, 29H  
MOV A, @R0  
MOV 40H, A
MOV 41H, A
INC R0
DEC R2
NEXT: 
MOV A, @R0
CJNE A,40H, CHK_L
SJMP CHK_S
CHK_L :
JC CHK_S
MOV 40H, A
CHK_S :
CJNE A,41H,CHK_S2
SJMP CONT
CHK_S2 :
JNC CONT 
MOV 41H,A
CONT:
INC R0
DJNZ R2, NEXT
HERE: SJMP HERE 
END